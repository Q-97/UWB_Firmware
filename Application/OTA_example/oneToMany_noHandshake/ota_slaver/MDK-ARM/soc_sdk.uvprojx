# Keil uVision project soc_sdk.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STAR_SE ArmChina
  pack: ArmChina.STAR.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: APP +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --text -a -c --output=Bin\@L.text !L
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __EN_ICACHE=1 __EN_DCACHE=1  SEED_METHOD=SEED_ARG COMPILER_VERSION=__VERSION__ COMPILER_FLAGS=\"-Omax\"  USE_MicrolLIB
  c misc: -Rpass=loop-delete
  c include: ..\..\..\..\..\CMSIS\Include;..\..\..\..\..\CMSIS\Device\ZN\ZNSOC\Include;..\..\..\..\..\Drivers\Soc\Inc;..\..\..\..\..\CmBacktrace;..\..\..\..\..\Drivers\Uwb\Inc;..\..\..\..\..\Phydebug\Inc;..\..\..\..\..\Hal\Inc;..\User\Inc;..\..\common\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x30000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  group App
    ../User/Src/: initiator.c kalman.c responder.c range.c main.c
  group Hal
    ../../../../../Hal/Src/: hal_adc.c hal_can.c hal_dca.c hal_delay.c hal_dma.c hal_flash.c hal_gp_timer.c hal_gpio.c hal_i2c.c hal_mem.c hal_otp.c hal_sleep.c hal_soc.c hal_spi.c hal_sys_timer.c hal_uart.c hal_uwb.c hal_watchdog.c
  group Drivers/ZNSOC_Driver
    ../../../../../Drivers/Soc/Src/: zn_aes.c zn_can.c zn_dca.c zn_delay.c zn_dma.c zn_gpio.c zn_i2c.c zn_log.c zn_qspi.c zn_qspi_gd25q40.c zn_spi.c zn_sys_tick.c zn_sys_timer.c zn_timer.c zn_uart.c zn_wdt.c
  group Drivers/UWB
    ../../../../../Drivers/Uwb/Src/: algo_phy.c zn_driver.c zn_rapid.c
  group CmBacktrace
    ../../../../../CmBacktrace/: cm_backtrace.c
  group MDK-ARM
    ../../../../../CMSIS/Device/ZN/ZNSOC/Source/Templates/: system_zn_soc.c
    ../../../../../CMSIS/Device/ZN/ZNSOC/Source/Templates/arm/: startup_zn_soc.s
  group PhyDebug
    ../../../../../Phydebug/Src/: phy_cmd.c phy_simple_rx.c phy_simple_tx.c phy_test.c
  group Common
    ../../common/Src/: ota.c
software components: CMSIS:CORE 5.5.0
