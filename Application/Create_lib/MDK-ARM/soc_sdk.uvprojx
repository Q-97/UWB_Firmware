# Keil uVision project soc_sdk.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STAR_SE ArmChina
  pack: ArmChina.STAR.1.3.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: algo_phy +hex (library)
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --text -a -c --output=Bin\@L.text !L
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c define: DISABLEFLOAT16  __EN_ICACHE=1 __EN_DCACHE=1  SEED_METHOD=SEED_ARG COMPILER_VERSION=__VERSION__ COMPILER_FLAGS=\"-Omax\"  USE_MicrolLIB
  c include: ..\..\..\CMSIS\Include;..\..\..\CMSIS\Device\ZN\ZNSOC\Include;..\..\..\Drivers\Soc\Inc;..\..\..\Drivers\Uwb\Inc;..\..\..\Hal\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  group Driver/UWB
    ../../../Drivers/Uwb/Src/: algo_phy.c zn_radar.c zn_rapid.c
  group MDK-ARM
    ../../../CMSIS/Device/ZN/ZNSOC/Source/Templates/arm/: startup_zn_soc.s
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.16.2
